# Keil uVision project stm32h723.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32h723 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Drivers\SYSTEM\delay;..\Drivers\SYSTEM\sys;..\Drivers\SYSTEM\uart1;..\Drivers\Modules\Motor;..\Drivers\Modules\Remote;..\Drivers\Application;..\Drivers\Algorithm;..\Drivers\BSP;..\User;..\Drivers\Application\Chassis;..\Drivers\Modules\IMU;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM7\r0p1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Startup
    ./: startup_stm32h723xx.s
  group User
    ../User/: main.c stm32h7xx_it.c system_stm32h7xx.c FreeRTOS_Text.c
  group Driver/BSP
    ../Drivers/BSP/: CAN.c TIM.c SPI.c
  group Driver/Modules/Motor
    ../Drivers/Modules/Motor/: Motor.c
  group Driver/Modules/Remote
    ../Drivers/Modules/Remote/: IBUS.c
  group Driver/Modules/IMU
    ../Drivers/Modules/IMU/: BMI088.c BMI088_Driver.c BMI088_Middleware.c BMI088_Reg.h
  group Driver/Algorithm
    ../Drivers/Algorithm/: PID.c Kalman.c
  group Driver/Application/Chassis
    ../Drivers/Application/Chassis/: Chassis.c
  group Driver/SYSTEM
    ../Drivers/SYSTEM/delay/: Delay.c
    ../Drivers/SYSTEM/sys/: sys.c
    ../Drivers/SYSTEM/uart1/: UART1.c
  group Driver/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c
    ../Drivers/STM32H7xx_HAL_Driver/Inc/: stm32h7xx_hal_conf_template.h
  group Middlewares/FreeRTOS_CORE
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c portmacro.h
software components: CMSIS:CORE 4.3.0
